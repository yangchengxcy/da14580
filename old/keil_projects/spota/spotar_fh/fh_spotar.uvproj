# Keil uVision project fh_spotar.uvproj, settings and files
target Full_emb_cortex_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: full_emb_sysram +hex
  c flags: Optim=4 wLevel=2
  c define: CFG_ES4 CFG_LUT_PATCH nCFG_EXT_SLEEP nCFG_WDOG CFG_NVDS CFG_EMB CFG_HOST CFG_APP CFG_GTL CFG_BLE CFG_HCI_UART CFG_EXT_DB  nCFG_DBG_MEM nCFG_RF_RIPPLE nCFG_DBG_FLASH  nCFG_DBG_NVDS  nCFG_DBG_STACK_PROF  CFG_RF_RIPPLE nCFG_PERIPHERAL  CFG_ALLROLES  CFG_CON=6  CFG_SECURITY_ON  CFG_ATTC CFG_ATTS CFG_PRF_BASS nCFG_PRF_PXPM nCFG_PRF_PXPR CFG_PRF_SPOTAR nCFG_PRF_FMPL nCFG_PRF_FMPT nCFG_PRF_HTPT  nCFG_PRF_HTPC  nCFG_PRF_DISC CFG_PRF_DISS  nCFG_PRF_BLPC  nCFG_PRF_BLPS  nCFG_PRF_HRPC nCFG_PRF_HRPS  nCFG_PRF_ACCEL  POWER_OFF_SLEEP CFG_BLECORE_11 RADIO_580 __NO_EMBEDDED_ASM CFG_APP_SEC
  c misc: --c99 --thumb -c
  c include: .\..\..\..\src\dialog\include;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\..\..\src\plf\refip\src\arch;.\..\..\..\src\plf\refip\src\arch\compiler\rvds;.\..\..\..\src\plf\refip\src\arch\boot\rvds;.\..\..\..\src\plf\refip\src\arch\ll\rvds;.\..\..\..\src\plf\refip\src\driver\reg;.\..\..\..\src\modules\common\api;.\..\..\..\src\modules\dbg\api;.\..\..\..\src\modules\display\api;.\..\..\..\src\modules\gtl\api;.\..\..\..\src\modules\ke\api;.\..\..\..\src\modules\nvds\api;.\..\..\..\src\modules\rf\api;.\..\..\..\src\modules\rwip\api;.\..\..\..\src\ip\ble\ll\src\rwble;.\..\..\..\src\ip\ble\ll\src\controller\em;.\..\..\..\src\ip\ble\ll\src\controller\llc;.\..\..\..\src\ip\ble\ll\src\controller\lld;.\..\..\..\src\ip\ble\ll\src\controller\llm;.\..\..\..\src\plf\refip\src\driver\led;.\..\..\..\src\plf\refip\src\driver\timer;.\..\..\..\src\plf\refip\src\driver\syscntl;.\..\..\..\src\plf\refip\src\driver\emi;.\..\..\..\src\plf\refip\src\driver\uart;.\..\..\..\src\plf\refip\src\driver\flash;.\..\..\..\src\plf\refip\src\driver\gpio;.\..\..\..\src\ip\ble\hl\src\host\att;.\..\..\..\src\ip\ble\hl\src\host\att\attc;.\..\..\..\src\ip\ble\hl\src\host\att\attm;.\..\..\..\src\ip\ble\hl\src\host\gap;.\..\..\..\src\ip\ble\hl\src\host\gap\gapc;.\..\..\..\src\ip\ble\hl\src\host\gap\gapm;.\..\..\..\src\ip\ble\hl\src\host\att\atts;.\..\..\..\src\ip\ble\hl\src\host\gatt;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattc;.\..\..\..\src\ip\ble\hl\src\host\gatt\gattm;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cc;.\..\..\..\src\ip\ble\hl\src\host\l2c\l2cm;.\..\..\..\src\ip\ble\hl\src\host\smp\smpc;.\..\..\..\src\ip\ble\hl\src\host\smp\smpm;.\..\..\..\src\ip\ble\hl\src\profiles;.\..\..\..\src\ip\ble\hl\src\profiles\accel;.\..\..\..\src\ip\ble\hl\src\profiles\bas\basc;.\..\..\..\src\ip\ble\hl\src\profiles\bas\bass;.\..\..\..\src\ip\ble\hl\src\profiles\blp;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blpc;.\..\..\..\src\ip\ble\hl\src\profiles\blp\blps;.\..\..\..\src\ip\ble\hl\src\profiles\dis\disc;.\..\..\..\src\ip\ble\hl\src\profiles\dis\diss;.\..\..\..\src\ip\ble\hl\src\profiles\find\findl;.\..\..\..\src\ip\ble\hl\src\profiles\find\findt;.\..\..\..\src\ip\ble\hl\src\profiles\hogp;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpbh;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpd;.\..\..\..\src\ip\ble\hl\src\profiles\hogp\hogprh;.\..\..\..\src\ip\ble\hl\src\profiles\hrp;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrpc;.\..\..\..\src\ip\ble\hl\src\profiles\hrp\hrps;.\..\..\..\src\ip\ble\hl\src\profiles\htp;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpc;.\..\..\..\src\ip\ble\hl\src\profiles\htp\htpt;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxm;.\..\..\..\src\ip\ble\hl\src\profiles\prox\proxr;.\..\..\..\src\ip\ble\hl\src\profiles\scpp;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scppc;.\..\..\..\src\ip\ble\hl\src\profiles\scpp\scpps;.\..\..\..\src\plf\refip\src\driver\intc;.\..\..\..\src\ip\ble\hl\src\rwble_hl;.\..\..\..\src\ip\ble\ll\src\hcic;.\..\..\..\src\ip\ble\hl\src\host\smp;.\..\..\..\src\modules\app\api;.\..\..\..\src\modules\gtl\src;.\..\..\..\src\ip\ble\hl\src\profiles\anp;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anpc;.\..\..\..\src\ip\ble\hl\src\profiles\anp\anps;.\..\..\..\src\ip\ble\hl\src\profiles\cscp;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscpc;.\..\..\..\src\ip\ble\hl\src\profiles\cscp\cscps;.\..\..\..\src\ip\ble\hl\src\profiles\glp;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glpc;.\..\..\..\src\ip\ble\hl\src\profiles\glp\glps;.\..\..\..\src\ip\ble\hl\src\profiles\pasp;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\paspc;.\..\..\..\src\ip\ble\hl\src\profiles\pasp\pasps;.\..\..\..\src\ip\ble\hl\src\profiles\rscp;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscpc;.\..\..\..\src\ip\ble\hl\src\profiles\rscp\rscps;.\..\..\..\src\ip\ble\hl\src\profiles\tip;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tipc;.\..\..\..\src\ip\ble\hl\src\profiles\tip\tips;.\..\..\..\src\ip\ble\hl\src\profiles\spota\spotar; .\..\..\..\src\modules\app\src\; .\..\..\..\src\modules\app\src\spotar
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: ..\..\..\scatterfiles\exchange_mem_es3_spotar.sct
  link misc: ..\..\..\misc\rom_symdef.txt  --symdefs=full_emb_sysram_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --datacompressor off
  group boot
    ./../../../src/plf/refip/src/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ../../../src/plf/refip/src/arch/main/ble/: hardfault_handler.c
  group arch
    ./../../../src/plf/refip/src/arch/main/ble/: arch_main.c jump_table.c
    ../../../src/plf/refip/src/arch/main/ble/: arch_sleep.c nmi_handler.c
  group driver
    ./../../../src/modules/rf/src/: rf_580.c
    ../../../src/plf/refip/src/driver/gpio/: gpio.c
    ../../../patch_obj/: rf_calibration.obj pll_vcocal_lut.obj
    ../../../src/plf/refip/src/driver/uart/: uart_init.c
  group host
    ./../../../src/ip/ble/hl/src/host/gap/gapm/: gapm.c
  group nvds
    ./../../../src/modules/nvds/src/: nvds.c
  group rwble
    ./../../../src/modules/rwip/src/: rwip.c
    ./../../../src/ip/ble/ll/src/rwble/: rwble.c
  group profiles
    ./../../../src/ip/ble/hl/src/profiles/accel/: accel.c accel_task.c
    ./../../../src/ip/ble/hl/src/profiles/bas/basc/: basc.c basc_task.c
    ./../../../src/ip/ble/hl/src/profiles/bas/bass/: bass.c bass_task.c
    ./../../../src/ip/ble/hl/src/profiles/blp/blpc/: blpc.c blpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/blp/blps/: blps.c blps_task.c
    ./../../../src/ip/ble/hl/src/profiles/dis/disc/: disc.c disc_task.c
    ./../../../src/ip/ble/hl/src/profiles/dis/diss/: diss.c diss_task.c
    ./../../../src/ip/ble/hl/src/profiles/find/findt/: findt.c findt_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogpbh/: hogpbh.c hogpbh_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ./../../../src/ip/ble/hl/src/profiles/hogp/hogprh/: hogprh.c hogprh_task.c
    ./../../../src/ip/ble/hl/src/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/hrp/hrps/: hrps.c hrps_task.c
    ./../../../src/ip/ble/hl/src/profiles/htp/htpc/: htpc.c htpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/htp/htpt/: htpt.c htpt_task.c
    ./../../../src/ip/ble/hl/src/profiles/prox/proxm/: proxm.c proxm_task.c
    ./../../../src/ip/ble/hl/src/profiles/prox/proxr/: proxr.c proxr_task.c
    ./../../../src/ip/ble/hl/src/profiles/scpp/scppc/: scppc.c scppc_task.c
    ./../../../src/ip/ble/hl/src/profiles/scpp/scpps/: scpps.c scpps_task.c
    ./../../../src/ip/ble/hl/src/profiles/: prf_utils.c
    ./../../../src/ip/ble/hl/src/profiles/anp/anpc/: anpc.c anpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/anp/anps/: anps.c anps_task.c
    ./../../../src/ip/ble/hl/src/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/cscp/cscps/: cscps.c cscps_task.c
    ./../../../src/ip/ble/hl/src/profiles/glp/glpc/: glpc.c glpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/glp/glps/: glps.c glps_task.c
    ./../../../src/ip/ble/hl/src/profiles/pasp/paspc/: paspc.c paspc_task.c
    ./../../../src/ip/ble/hl/src/profiles/pasp/pasps/: pasps.c pasps_task.c
    ./../../../src/ip/ble/hl/src/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ./../../../src/ip/ble/hl/src/profiles/rscp/rscps/: rscps.c rscps_task.c
    ./../../../src/ip/ble/hl/src/profiles/tip/tipc/: tipc.c tipc_task.c
    ./../../../src/ip/ble/hl/src/profiles/tip/tips/: tips.c tips_task.c
    ../../../src/ip/ble/hl/src/profiles/find/findl/: findl.c findl_task.c
    ../../../src/ip/ble/hl/src/profiles/spota/spotar/: spotar.c spotar_task.c
  group app
    ./../../../src/modules/app/src/: app.c app_sec.c app_sec_task.c app_task.c app_proxr.c app_button_led.c
    ../../../src/modules/app/src/: app_batt.c app_batt_task.c app_dis.c app_dis_task.c
    ../../../src/modules/app/src/spotar/: app_spotar_task.c app_spotar_proj.c app_spotar.c
  group ke
    ../../../src/modules/ke/src/: ke_task.c
  group controller
    ../../../patch_obj/: lld.obj lld_data.obj lld_evt.obj llm.obj
